# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\HARDWARE\OLED-IIC;.\HARDWARE;.\HARDWARE\Soure
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group USER
    ./: blinkLED.c
  group Driverlib
    ./HARDWARE/Soure/: adc14.c aes256.c comp_e.c cpu.c crc32.c cs.c dma.c flash.c flash_a.c fpu.c i2c.c interrupt.c lcd_f.c mpu.c pcm.c pmap.c pss.c ref_a.c reset.c rtc_c.c spi.c sysctl.c sysctl_a.c systick.c timer_a.c timer32.c wdt_a.c gpio.c uart.c
  group HARDWARE
    ./HARDWARE/OLED-IIC/: ASCII.C bsp_oled12864.c bsp_i2c_gpio.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
